Properties of the parts of a building model (IFC4)

# File
Description: ViewDefinition [DesignTransferView_V1.0]
File name: S:\Nyffenegger\457872\Ständerset_457872.ifc
Time: 2025-09-23T16:46:39
Written by: bSystem 2.0 with IfcPlusPlus
Made in: Bausoft Haustech-CAD Version 2.71.0.15

# IfcProject, DefaultProject
Description: Bauvorhaben

# IfcBuildingStorey, DefaultStorey
In: DefaultBuilding
Elevation: 0 m

# IfcDistributionFlowElement, Fussstützen mit Befestigung
In: DefaultStorey
Description: Fussstützen mit Befestigung; Group: Ständerset
Nyffenegger - Bezeichnung: Ständerset 457872; Gewerk: Sanitär; Geschoss: DefaultStorey; System: Ständerset; Layer: Ständerset
Summary - Name: Fussstützen mit Befestigung; Beschreibung: Fussstützen mit Befestigung; Typ: Fussstützen mit Befestigung; Bezeichnung: Ständerset 457872; Gewerk: Sanitär; Geschoss: DefaultStorey; System: Ständerset; Layer: Ständerset
