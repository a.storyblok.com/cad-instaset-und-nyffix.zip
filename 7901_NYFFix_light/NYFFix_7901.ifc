Properties of the parts of a building model (IFC4)

# File
Description: ViewDefinition [DesignTransferView_V1.0]
File name: S:\Nyffenegger\7901\NYFFix_7901.ifc
Time: 2025-09-23T15:53:51
Written by: bSystem 2.0 with IfcPlusPlus
Made in: Bausoft Haustech-CAD Version 2.71.0.15

# IfcProject, DefaultProject
Description: Bauvorhaben

# IfcBuildingStorey, DefaultStorey
In: DefaultBuilding
Elevation: 0 m

# IfcDistributionFlowElement, Küchenelement
In: DefaultStorey
Description: Küchenelement; Group: Installationsplatte
Nyffenegger - Bezeichnung: NYFFix light 7901; Gewerk: Sanitär; Geschoss: DefaultStorey; System: Installationsplatte; Layer: Installationsplatte
Summary - Name: Küchenelement; Beschreibung: Küchenelement; Typ: Küchenelement; Bezeichnung: NYFFix light 7901; Gewerk: Sanitär; Geschoss: DefaultStorey; System: Installationsplatte; Layer: Installationsplatte
