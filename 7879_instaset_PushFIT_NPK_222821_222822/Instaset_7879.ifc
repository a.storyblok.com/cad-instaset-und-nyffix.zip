Properties of the parts of a building model (IFC4)

# File
Description: ViewDefinition [DesignTransferView_V1.0]
File name: S:\Nyffenegger\7879\Instaset_7879.ifc
Time: 2025-09-23T15:42:09
Written by: bSystem 2.0 with IfcPlusPlus
Made in: Bausoft Haustech-CAD Version 2.71.0.15

# IfcProject, DefaultProject
Description: Bauvorhaben

# IfcBuildingStorey, DefaultStorey
In: DefaultBuilding
Elevation: 0 m

# IfcDistributionFlowElement, Instaset
In: DefaultStorey
Description: Instaset; Group: Instaset für Spültisch
Nyffenegger - Bezeichnung: Instaset 7879; Gewerk: Sanitär; Geschoss: DefaultStorey; System: Instaset für Spültisch; Layer: Instaset für Spültisch
Summary - Name: Instaset; Beschreibung: Instaset; Typ: Instaset; Bezeichnung: Instaset 7879; Gewerk: Sanitär; Geschoss: DefaultStorey; System: Instaset für Spültisch; Layer: Instaset für Spültisch
