Properties of the parts of a building model (IFC4)

# File
Description: ViewDefinition [DesignTransferView_V1.0]
File name: S:\Nyffenegger\7920 L\NYFFix_7920L.ifc
Time: 2025-09-02T11:19:54
Written by: bSystem 2.0 with IfcPlusPlus
Made in: Bausoft Haustech-CAD Version 2.72.0.34

# IfcProject, DefaultProject
Description: Bauvorhaben

# IfcDistributionFlowElement, Küchenelement
In: DefaultStorey
Description: Küchenelement; Group: Nyffenegger
Nyffenegger - Bezeichnung: NYFFix 7920 L; Gewerk: Sanitär; Geschoss: DefaultStorey; System: Nyffenegger; Layer: Nyffenegger
Summary - Name: Küchenelement; Beschreibung: Küchenelement; Typ: Küchenelement; Bezeichnung: NYFFix 7920 L; Gewerk: Sanitär; Geschoss: DefaultStorey; System: Nyffenegger; Layer: Nyffenegger
