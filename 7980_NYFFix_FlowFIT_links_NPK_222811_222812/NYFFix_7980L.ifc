Properties of the parts of a building model (IFC4)

# File
Description: ViewDefinition [DesignTransferView_V1.0]
File name: S:\Nyffenegger\7980 L\NYFFix_7980L.ifc
Time: 2025-09-23T16:14:59
Written by: bSystem 2.0 with IfcPlusPlus
Made in: Bausoft Haustech-CAD Version 2.71.0.15

# IfcProject, DefaultProject
Description: Bauvorhaben

# IfcBuildingStorey, DefaultStorey
In: DefaultBuilding
Elevation: 0 m

# IfcDistributionFlowElement, Küchenelement
In: DefaultStorey
Description: Küchenelement
Nyffenegger - Bezeichnung: NYFFix 7980 L; Gewerk: Sanitär; Geschoss: DefaultStorey
Summary - Name: Küchenelement; Beschreibung: Küchenelement; Typ: Küchenelement; Bezeichnung: NYFFix 7980 L; Gewerk: Sanitär; Geschoss: DefaultStorey
